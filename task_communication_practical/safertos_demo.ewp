# IAR project safertos_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM3SxBxx Luminary LM3SxBxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; PART_LM3S9B96; TARGET_IS_TEMPEST_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: C:\StellarisWare; C:\StellarisWare\boards; C:\StellarisWare\boards\dk-lm3s9b96; C:\StellarisWare\third_party\lwip-1.3.1\apps; C:\StellarisWare\third_party\lwip-1.3.1\ports\stellaris\include; C:\StellarisWare\third_party\lwip-1.3.1\src\include; C:\StellarisWare\third_party\lwip-1.3.1\src\include\ipv4; C:\StellarisWare\third_party
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: .; ..; ..\..\..; ..\..\..\third_party\lwip-1.3.1\apps; ..\..\..\third_party\lwip-1.3.1\ports\stellaris\include; ..\..\..\third_party\lwip-1.3.1\src\include; ..\..\..\third_party\lwip-1.3.1\src\include\ipv4; ..\..\..\third_party
  OBJCOPY.OOCOutputFile: safertos_demo.bin
  ILINK.IlinkOutputFile: safertos_demo.out
  ILINK.IlinkIcfFile: safertos_demo.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    C:/StellarisWare/driverlib/ewarm/Exe/: driverlib.a
    C:/StellarisWare/grlib/ewarm/Exe/: grlib.a
  group Source
    ./: display_task.c idle_task.c images.c led_task.c safertos_demo.c spider_task.c
  group Source/External
    C:/StellarisWare/boards/dk-lm3s9b96/drivers/: kitronix320x240x16_ssd2119_8bit.c set_pinout.c touch.c
    ./: random.c startup_ewarm.c
    C:/StellarisWare/utils/: ustdlib.c
